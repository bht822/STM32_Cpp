# Keil uVision project stm32F411RE_Drivers.uvprojx, settings and files
target stm32F411RE (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32F411RE_Drivers
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group app
    ./: main.cpp mcal_reg_access.h mcal_reg_access_dynamic.h mcal_reg.h uart.cpp uart.h systick.cpp systick.h timer2.cpp timer2.h adc.cpp adc.h i2c.cpp i2c.h
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
